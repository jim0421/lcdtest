# Keil uVision project LcdTest.uvproj, settings and files
target LiftLcd_Test (ARM-ADS)
  device: LPC2468 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x4000FFFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: ..\ZBinFile\LiftLcd_Test +hex
  AfterMake: C:\Users\艺雯\Desktop\LCDTest\LCDTest\PRJ_RTX\tobin.bat
  c flags: Optim=1
  c include: ..\INC;..\DRV;..\LcdPrg
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0xa0000000 size 0x800000
  memory RVCT9: RAM 0x40000000 size 0x10000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group OSL
    ../OSL/: LPC2400_RTX.s syscall.c tick.c Retarget.c command.c irq.c SWI_table.s RTX2_Config.c osenv.c debug_print.cpp
  group DRV
    ../DRV/: device_manage_RTX.c watchdog.c timer1.c ioport.c lpc22xxuartBase.cpp LCD050I64BIO.c
  group APPS
    ../APPS/: sys_init.c tty_control.c vt100.c brake_main.cpp
  group DRV2
    ../DRV2/: drv2.c GB_Table.c LCD_ASCII.c LCD050I64.c LCD_Dis.c
  group LcdPrg
    ../LcdPrg/: Components.cpp LcdTestMain.cpp MyComponents.cpp Utility.cpp Words.cpp components.h graphics.h resource.h utility.h words.h
target LiftLcd_S4 (ARM-ADS)
  device: LPC2468 NXP (founded by Philips)
  cpu: as above
  output: LiftLcd_S4 +hex
  AfterMake: C:\Users\艺雯\Desktop\LCDTest\LCDTest\PRJ_RTX\tobin.bat
  c flags: Optim=4
  c include: ..\INC;..\DRV;..\LcdPrg
  asm define: REMAP RAM_MODE RAM_INTVEC
  memory RVCT4: ROM 0x5000 size 0x7b000
  memory RVCT6: RAM 0xa0000000 size 0x800000
  memory RVCT9: RAM 0x40000040 size 0xffc0
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  link misc: --entry 0x5000
